# Keil uVision project YT32B1_STM32F103_demo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: YT32B1_STM32F103_demo +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\User;.\Startup;.\Basic\delay;.\Basic\sys;.\Hardware\LED;.\Hardware\KEY;.\Basic\flash;.\Hardware\BUZZER;.\Basic\usart;.\Basic\rtc;.\Hardware\TOUCH_KEY;.\Basic\i2c;.\Hardware\OLED0561;.\Hardware\DS18B20;.\Basic\nvic;.\Hardware\RELAY;.\Basic\adc;.\Basic\pwm;.\Hardware\DS18B20_2;.\Hardware\ChangeWatIoConfig
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_tim.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/flash/: flash.c
    ./Basic/usart/: usart.c
    ./Basic/rtc/: rtc.c
    ./Basic/i2c/: i2c.c
    ./Basic/nvic/: NVIC.c
    ./Basic/adc/: adc.c
    ./Basic/pwm/: pwm.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/KEY/: key.c
    ./Hardware/BUZZER/: buzzer.c
    ./Hardware/TOUCH_KEY/: touch_key.c
    ./Hardware/OLED0561/: oled0561.c
    ./Hardware/DS18B20/: ds18b20.c
    ./Hardware/RELAY/: relay.c
    ./Hardware/DS18B20_2/: ds18b20_2.c
    ./Hardware/ChangeWatIoConfig/: ChangeWatIoConfig.c
